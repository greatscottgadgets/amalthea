options:
  parameters:
    author: mike
    generate_options: qt_gui
    id: hybridsdr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amalthea_device_0
  id: amalthea_device
  parameters: {}
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: amalthea_source_0
  id: amalthea_source
  parameters:
    freq: 2450e6
    sample_rate: samp_rate
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2'
    n: '4'
    offset: '0'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/32768.
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from luna import top_level_cli
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      top_level_cli(self.amalthea_device)
      time.sleep(8)
    priority: ''
    section: main_after_init
  states: {}

connections:
- [amalthea_source_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_multiply_const_vxx_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
