options:
  parameters:
    author: mike
    generate_options: qt_gui
    id: hybridsdr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amalthea_device_0
  id: amalthea_device
  parameters: {}
  states: {}
- name: amalthea_demod_0
  id: amalthea_demod
  parameters:
    type: hybridsdr
  states: {}
- name: amalthea_rx_0
  id: amalthea_rx
  parameters: {}
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from luna import top_level_cli
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: top_level_cli(self.amalthea_device)
    priority: ''
    section: main_after_init
  states: {}

connections:
- [amalthea_demod_0, '0', blocks_null_sink_0_0_1, '0']
- [amalthea_demod_0, '1', blocks_null_sink_0_0, '0']
- [amalthea_rx_0, '0', amalthea_demod_0, '0']
- [amalthea_rx_0, '0', blocks_null_sink_0_0_0, '0']

metadata:
  file_format: 1
