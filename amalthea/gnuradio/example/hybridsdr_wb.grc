options:
  parameters:
    author: mike
    generate_options: qt_gui
    id: hybridsdr_wb
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amalthea_device_0
  id: amalthea_device
  parameters: {}
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: amalthea_demod_0
  id: amalthea_demod
  parameters: {}
  states: {}
- name: amalthea_rx_0
  id: amalthea_rx
  parameters: {}
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from luna import top_level_cli
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '10240'
    srate: samp_rate
    type: float
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      top_level_cli(self.amalthea_device)
      time.sleep(10)
      self.amalthea_device.finalize_usb_connections(self)
    priority: ''
    section: main_after_init
  states: {}
- name: wishbone_counter_0
  id: wishbone_counter
  parameters: {}
  states: {}

connections:
- [amalthea_demod_0, '0', qtgui_time_sink_x_0, '0']
- [amalthea_demod_0, '1', qtgui_time_sink_x_0, '1']
- [amalthea_rx_0, '0', amalthea_demod_0, '0']
- [amalthea_rx_0, '0', fosphor_qt_sink_c_0, '0']
- [wishbone_counter_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
